## drivers/kmem_proxy/Kconfig
```kconfig
config KMEM_PROXY
	bool "Kernel Memory Proxy Driver"
	default y
	help
	  Private supervisor memory proxy device.
```
